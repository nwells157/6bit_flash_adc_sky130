v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 40 -90 {}
C {ipin.sym} 70 -150 0 0 {name=p1 lab=VDD}
C {ipin.sym} 70 -130 0 0 {name=p2 lab=VSS}
C {ipin.sym} 70 -110 0 0 {name=p3 lab=ref[5:0]}
C {ipin.sym} 70 -90 0 0 {name=p4 lab=VIN[5:0]}
C {opin.sym} 170 -150 0 0 {name=p5 lab=vout[5:0]}
