v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/home/nwells/xschem/6_bit_flash/schematics/adc_top.sym} 160 -110 0 0 {name=x1}
