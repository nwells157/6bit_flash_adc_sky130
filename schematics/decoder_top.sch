v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 130 -130 {}
C {devices/ipin.sym} 180 -170 0 0 {name=p1 lab=decode_in[62..0]}
C {devices/ipin.sym} 180 -210 0 0 {name=p2 lab=VDD}
C {devices/ipin.sym} 180 -190 0 0 {name=p3 lab=VSS}
C {devices/opin.sym} 240 -210 0 0 {name=p4 lab=OUT[5..0]}
