v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {schematics/ref_ladder_top.sym} 260 -270 0 0 {name=x1}
C {devices/lab_pin.sym} 110 -260 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 110 -280 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 410 -280 0 1 {name=p1 lab=vref[62..0]}
C {devices/lab_pin.sym} 990 -300 0 1 {name=p2 lab=vout[5:0]}
C {devices/lab_pin.sym} 690 -300 0 0 {name=p4 lab=VDD}
C {devices/lab_pin.sym} 690 -280 0 0 {name=p5 lab=VSS}
C {devices/lab_pin.sym} 690 -260 0 0 {name=p6 lab=ref[5:0]}
C {devices/lab_pin.sym} 690 -240 0 0 {name=p7 lab=VIN[5:0]}
C {schematics/comp_top_ideal.sym} 840 -270 0 0 {name=x2}
