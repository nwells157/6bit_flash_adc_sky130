v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {lab_pin.sym} 110 -280 0 0 {name=p1 lab=VDD}
C {lab_pin.sym} 110 -260 0 0 {name=p3 lab=VSS}
C {lab_pin.sym} 410 -280 0 1 {name=p2 lab=vref[62..0]}
C {lab_pin.sym} 990 -300 0 1 {name=p4 lab=vout[62..0]}
C {lab_pin.sym} 690 -300 0 0 {name=p5 lab=VDD}
C {lab_pin.sym} 690 -280 0 0 {name=p6 lab=VSS}
C {lab_pin.sym} 690 -260 0 0 {name=p7 lab=vref[62..0]}
C {lab_pin.sym} 690 -240 0 0 {name=p8 lab=VIN}
C {/home/nwells/xschem/6_bit_flash/schematics/ref_ladder_top.sym} 260 -270 0 0 {name=x1}
C {/home/nwells/xschem/6_bit_flash/schematics/comp_top.sym} 840 -270 0 0 {name=x2}
