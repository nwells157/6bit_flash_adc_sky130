v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 80 -140 0 0 {name=p1 lab=in0
}
C {devices/ipin.sym} 80 -120 0 0 {name=p2 lab=in1
}
C {devices/ipin.sym} 80 -100 0 0 {name=p3 lab=in2
}
C {devices/ipin.sym} 80 -80 0 0 {name=p4 lab=in3
}
C {devices/ipin.sym} 80 -60 0 0 {name=p5 lab=in4
}
C {devices/ipin.sym} 80 -40 0 0 {name=p6 lab=in5
}
C {devices/ipin.sym} 80 -220 0 0 {name=p7 lab=vdd
}
C {devices/opin.sym} 150 -220 0 0 {name=p9 lab=out}
C {devices/ipin.sym} 80 -200 0 0 {name=p8 lab=vss
}
C {devices/ipin.sym} 80 -180 0 0 {name=p10 lab=vref
}
