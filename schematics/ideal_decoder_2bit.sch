v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 100 -220 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} 100 -200 0 0 {name=p2 lab=vss}
C {devices/ipin.sym} 100 -180 0 0 {name=p3 lab=vref}
C {devices/ipin.sym} 100 -140 0 0 {name=p4 lab=in0}
C {devices/opin.sym} 160 -220 0 0 {name=p5 lab=out0}
C {devices/ipin.sym} 100 -120 0 0 {name=p6 lab=in1}
C {devices/ipin.sym} 100 -100 0 0 {name=p7 lab=in2}
C {devices/ipin.sym} 100 -80 0 0 {name=p8 lab=in3}
C {devices/opin.sym} 160 -200 0 0 {name=p9 lab=out1}
