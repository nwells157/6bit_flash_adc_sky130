v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 90 -50 {}
N 580 -390 620 -390 {lab=vout[62..0]}
C {devices/opin.sym} 180 -110 0 0 {name=p11 lab=vout[62..0]}
C {devices/ipin.sym} 140 -110 0 0 {name=p5 lab=VDD}
C {devices/ipin.sym} 140 -90 0 0 {name=p7 lab=VSS}
C {devices/ipin.sym} 140 -70 0 0 {name=p8 lab=vref[62..0]}
C {devices/ipin.sym} 140 -50 0 0 {name=p9 lab=VIN}
C {devices/lab_pin.sym} 280 -370 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 -330 0 0 {name=p12 sig_type=std_logic lab=vref[62..0]}
C {devices/lab_pin.sym} 280 -350 0 0 {name=p13 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} 280 -390 0 0 {name=p14 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 620 -390 0 1 {name=p15 sig_type=std_logic lab=vout[62..0]}
C {schematics/comp.sym} 430 -360 0 0 {name=xCOMP[62..0]}
