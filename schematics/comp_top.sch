v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 240 -40 {}
C {devices/ipin.sym} 130 -110 0 0 {name=p6 lab=VDD}
C {devices/ipin.sym} 130 -90 0 0 {name=p1 lab=VSS}
C {devices/ipin.sym} 130 -50 0 0 {name=p2 lab=VIN[5:0]}
C {devices/ipin.sym} 130 -70 0 0 {name=p4 lab=ref[5:0]}
C {devices/opin.sym} 180 -110 0 0 {name=p3 lab=vout[5:0]}
