v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 200 -1100 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} 200 -1070 0 0 {name=p2 lab=vss}
C {devices/ipin.sym} 200 -1040 0 0 {name=p3 lab=vref}
C {devices/ipin.sym} 360 -1100 0 0 {name=p64 lab=dec_in[62..0]}
C {devices/opin.sym} 400 -1100 0 0 {name=p67 lab=out[5..0]}
